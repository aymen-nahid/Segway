# Keil uVision project 2018-01_RTOS-project.uvprojx, settings and files
target 2018-01_RTOS-project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20013FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 2018-01_RTOS-project
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;..\Drivers\MeSN\i2c;..\Drivers\MeSN\LSM6DS3;..\Drivers\MeSN\MotorDriver;..\Drivers\MeSN\UART;..\Libs
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x14000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l152xe.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal.c stm32l1xx_hal_pwr.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash.c stm32l1xx_hal_rcc.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_uart.c
  group Application/User
    ../Src/: stm32l1xx_it.c stm32l1xx_hal_msp.c main.c usart.c stm32l1xx_hal_timebase_TIM.c freertos.c tim.c i2c.c gpio.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: tasks.c event_groups.c timers.c list.c queue.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/MeSN/UART
    ../Drivers/MeSN/UART/: MeSN_uart_OS.c
  group Drivers/MeSN/I2C
    ../Drivers/MeSN/i2c/: MeSN_i2c.c
  group Drivers/MeSN/LSM6DS3
    ../Drivers/MeSN/LSM6DS3/: lsm6ds3.c lsm6ds3_port.c
  group Drivers/MeSN/MotorDriver
    ../Drivers/MeSN/MotorDriver/: MeSN_MotorDriver.c MeSN_MotorDriver_port.c
  group Application/Regulation
    ../Libs/: regulation.lib
software components: CMSIS:CORE 4.1.0
